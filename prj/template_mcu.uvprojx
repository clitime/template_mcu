# Keil uVision project template_mcu.uvprojx, settings and files
target firm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f427_template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx
  c include: ..\src\config;..\lib\spl\CMSIS\Include;..\lib\spl\CMSIS\Device\ST\STM32F4xx\Include;..\lib\spl\STM32F4xx_StdPeriph_Driver\inc;..\src\firm;..\src\system;..\src\drivers;..\lib\FreeRTOS\Source\include;..\lib\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\src\debug
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../src/system/: startup_stm32f427_437xx.s
  group spl
    ../lib/spl/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c
  group stc/firm
    ../src/firm/: main.c mainTask.c
  group src/drivers
    ../src/drivers/: inout.c
  group src/system
    ../src/system/: system_stm32f4xx.c freeRTOS_debug.c
  group freeRTOS
    ../lib/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../lib/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../lib/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group src/debug
    ../src/debug/: debugTask.c
